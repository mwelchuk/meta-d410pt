FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://r8169.cfg"
